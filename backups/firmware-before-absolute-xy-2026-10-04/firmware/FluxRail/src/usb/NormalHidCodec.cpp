#include "NormalHidCodec.h"
namespace fluxrail {
namespace usb {
// 独立非boot键盘接口，无Report ID：8个修饰位+224个usage位，29字节。
// 普通Keyboard六键数组及boot切换不参与本工程，不发生六键截断。
const uint8_t kKeyboardDescriptor[] = {
    0x05, 0x01, 0x09, 0x06, 0xa1, 0x01, 0x05, 0x07, 0x19, 0xe0, 0x29, 0xe7,
    0x15, 0x00, 0x25, 0x01, 0x75, 0x01, 0x95, 0x08, 0x81, 0x02, 0x19, 0x00,
    0x29, 0xdf, 0x75, 0x01, 0x95, 0xe0, 0x81, 0x02,
    // 可选主机锁定灯output，不把Num/Caps等同于十键灯效配置。
    0x05, 0x08, 0x19, 0x01, 0x29, 0x05, 0x75, 0x01, 0x95, 0x05, 0x91, 0x02,
    0x75, 0x03, 0x95, 0x01, 0x91, 0x03, 0xc0};
const uint16_t kKeyboardDescriptorBytes = sizeof(kKeyboardDescriptor);
// 唯一第二HID接口：ID1相对X/Y与三按钮；ID2只有绝对X，没有绝对Y/重复按钮。
// 仅X集合的主机支持尚需Windows/游戏实测；编码不偷偷退回相对积分。
const uint8_t kMouseDescriptor[] = {
    0x05, 0x01, 0x09, 0x02, 0xa1, 0x01, 0x85, 0x01, 0x09, 0x01, 0xa1, 0x00,
    0x05, 0x09, 0x19, 0x01, 0x29, 0x03, 0x15, 0x00, 0x25, 0x01, 0x75, 0x01,
    0x95, 0x03, 0x81, 0x02, 0x75, 0x05, 0x95, 0x01, 0x81, 0x03, 0x05, 0x01,
    0x09, 0x30, 0x09, 0x31, 0x16, 0x00, 0x80, 0x26, 0xff, 0x7f, 0x75, 0x10,
    0x95, 0x02, 0x81, 0x06, 0xc0, 0xc0, 0x05, 0x01, 0x09, 0x02, 0xa1, 0x01,
    0x85, 0x02, 0x09, 0x01, 0xa1, 0x00, 0x09, 0x30, 0x15, 0x00, 0x26, 0xff,
    0x7f, 0x75, 0x10, 0x95, 0x01, 0x81, 0x02, 0xc0, 0xc0};
const uint16_t kMouseDescriptorBytes = sizeof(kMouseDescriptor);
void encodeKeyboard(const common::KeyboardState &state,
                    uint8_t out[kKeyboardPayloadBytes]) {
  out[0] = state.modifiers;
  for (uint8_t i = 0; i < 28; ++i)
    out[1 + i] = state.keys[i];
  // 00..03为无键/错误usage，A5..DF为当前不支持保留区；防外部快照绕过验证。
  out[1] &= 0xf0;
  out[1 + (0xa4 >> 3)] &= 0x1f;
  for (uint8_t i = (0xa4 >> 3) + 1; i < 28; ++i)
    out[1 + i] = 0;
}
bool encodeAbsoluteX(float output, uint8_t out[kAbsolutePayloadBytes]) {
  if (!(output >= 0 && output <= 1))
    return false; // 同时拒绝NaN/Inf。
  const uint16_t v = static_cast<uint16_t>(output * 32767.0f + 0.5f);
  out[0] = static_cast<uint8_t>(v);
  out[1] = static_cast<uint8_t>(v >> 8);
  return true;
}
void encodeRelativeMouse(uint8_t buttons, int16_t x, int16_t y,
                         uint8_t out[kMousePayloadBytes]) {
  out[0] = buttons & 7;
  const uint16_t ux = static_cast<uint16_t>(x), uy = static_cast<uint16_t>(y);
  out[1] = static_cast<uint8_t>(ux);
  out[2] = static_cast<uint8_t>(ux >> 8);
  out[3] = static_cast<uint8_t>(uy);
  out[4] = static_cast<uint8_t>(uy >> 8);
}
} // namespace usb
} // namespace fluxrail
